# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c ST7920.c delay.c DS1302.c Interface.c key.c i2c.c AM2320.c 18b20.c key.h
